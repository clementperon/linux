## drivers/net/wireless/rtl8189fs/Kconfig
```kconfig
config RTL8189FS
	tristate "Realtek 8189F SDIO or SPI WiFi"
	---help---
	  Help message of RTL8189FS
	  
```
